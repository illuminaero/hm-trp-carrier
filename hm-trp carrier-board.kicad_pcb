# Repository illuminaero/hm-trp-carrier

File README.md:

# hm-trp-carrier-board
hm-trp carrier-board PCB designed in KiCad

## KiCad design hm-trp carrier-board.kicad_pcb

Parts:
J1: Conn_01x06; WAFER-GH1.25-6PWB; LCSC C3029381
J2: Conn_Coaxial; U.FL_Molex_MCRF_73412-0110_Vertical; LCSC C88373
U1: HM-TRP

Connections:
/Config: J1.5, U1.5 (CONFIG)
/DRX: J1.4, U1.4 (DRX)
/DTX: J1.2, U1.2 (DTX)
/Enable: J1.6, U1.6 (ENABLE)
/Vcc: J1.1, U1.1 (Vcc)
GND: J1.3, J2.2 (Ext), U1.3 (GND), U1.8 (GND)
unnamed: J2.1 (In), U1.9 (ANT)

Board: 2 copper layers, 16.1 x 38.0 mm, 3 parts (0 on the bottom side), 7 nets.

File production/BOM Single.xlsx:

Designator | Footprint | Quantity | Value | LCSC Part #
J1 | WAFER-GH1.25-6PWB | 1 | Conn_01x06 | C3029381
J2 | U.FL_Molex_MCRF_73412-0110_Vertical | 1 | Conn_Coaxial | C88373

## KiCad design Pannel/pcb pannel.kicad_pcb

Board: 2 copper layers, 88.2 x 92.1 mm, 346 parts (0 on the bottom side), 70 nets.

Parts:
J1, J1#2, J1#3, J1#4, J1#5, J1#6, J1#7, J1#8, J1#9, J1#10: Conn_01x06; WAFER-GH1.25-6PWB
J2, J2#2, J2#3, J2#4, J2#5, J2#6, J2#7, J2#8, J2#9, J2#10: Conn_Coaxial; U.FL_Molex_MCRF_73412-0110_Vertical
KiKit_MB_1_1, KiKit_MB_1_2, KiKit_MB_1_3, KiKit_MB_1_4, KiKit_MB_1_5, KiKit_MB_1_6, KiKit_MB_2_1, KiKit_MB_2_2, KiKit_MB_2_3, KiKit_MB_2_4, KiKit_MB_2_5, KiKit_MB_2_6, KiKit_MB_3_1, KiKit_MB_3_2, KiKit_MB_3_3, KiKit_MB_3_4, KiKit_MB_3_5, KiKit_MB_3_6, KiKit_MB_4_1, KiKit_MB_4_2, KiKit_MB_4_3, KiKit_MB_4_4, KiKit_MB_4_5, KiKit_MB_4_6, KiKit_MB_5_1, KiKit_MB_5_2, KiKit_MB_5_3, KiKit_MB_5_4, KiKit_MB_5_5, KiKit_MB_5_6, KiKit_MB_6_1, KiKit_MB_6_2, KiKit_MB_6_3, KiKit_MB_6_4, KiKit_MB_6_5, KiKit_MB_6_6, KiKit_MB_7_1, KiKit_MB_7_2, KiKit_MB_7_3, KiKit_MB_7_4, KiKit_MB_7_5, KiKit_MB_7_6, KiKit_MB_8_1, KiKit_MB_8_2, KiKit_MB_8_3, KiKit_MB_8_4, KiKit_MB_8_5, KiKit_MB_8_6, KiKit_MB_9_1, KiKit_MB_9_2, KiKit_MB_9_3, KiKit_MB_9_4, KiKit_MB_9_5, KiKit_MB_9_6, KiKit_MB_10_1, KiKit_MB_10_2, KiKit_MB_10_3, KiKit_MB_10_4, KiKit_MB_10_5, KiKit_MB_10_6, KiKit_MB_11_1, KiKit_MB_11_2, KiKit_MB_11_3, KiKit_MB_11_4, KiKit_MB_11_5, KiKit_MB_11_6, KiKit_MB_12_1, KiKit_MB_12_2, KiKit_MB_12_3, KiKit_MB_12_4, KiKit_MB_12_5, KiKit_MB_12_6, KiKit_MB_13_1, KiKit_MB_13_2, KiKit_MB_13_3, KiKit_MB_13_4, KiKit_MB_13_5, KiKit_MB_13_6, KiKit_MB_14_1, KiKit_MB_14_2, KiKit_MB_14_3, KiKit_MB_14_4, KiKit_MB_14_5, KiKit_MB_14_6, KiKit_MB_15_1, KiKit_MB_15_2, KiKit_MB_15_3, KiKit_MB_15_4, KiKit_MB_15_5, KiKit_MB_15_6, KiKit_MB_16_1, KiKit_MB_16_2, KiKit_MB_16_3, KiKit_MB_16_4, KiKit_MB_16_5, KiKit_MB_16_6, KiKit_MB_17_1, KiKit_MB_17_2, KiKit_MB_17_3, KiKit_MB_17_4, KiKit_MB_17_5, KiKit_MB_17_6, KiKit_MB_18_1, KiKit_MB_18_2, KiKit_MB_18_3, KiKit_MB_18_4, KiKit_MB_18_5, KiKit_MB_18_6, KiKit_MB_19_1, KiKit_MB_19_2, KiKit_MB_19_3, KiKit_MB_19_4, KiKit_MB_19_5, KiKit_MB_19_6, KiKit_MB_20_1, KiKit_MB_20_2, KiKit_MB_20_3, KiKit_MB_20_4, KiKit_MB_20_5, KiKit_MB_20_6, KiKit_MB_21_1, KiKit_MB_21_2, KiKit_MB_21_3, KiKit_MB_21_4, KiKit_MB_21_5, KiKit_MB_21_6, KiKit_MB_22_1, KiKit_MB_22_2, KiKit_MB_22_3, KiKit_MB_22_4, KiKit_MB_22_5, KiKit_MB_22_6, KiKit_MB_23_1, KiKit_MB_23_2, KiKit_MB_23_3, KiKit_MB_23_4, KiKit_MB_23_5, KiKit_MB_23_6, KiKit_MB_24_1, KiKit_MB_24_2, KiKit_MB_24_3, KiKit_MB_24_4, KiKit_MB_24_5, KiKit_MB_24_6, KiKit_MB_25_1, KiKit_MB_25_2, KiKit_MB_25_3, KiKit_MB_25_4, KiKit_MB_25_5, KiKit_MB_25_6, KiKit_MB_26_1, KiKit_MB_26_2, KiKit_MB_26_3, KiKit_MB_26_4, KiKit_MB_26_5, KiKit_MB_26_6, KiKit_MB_27_1, KiKit_MB_27_2, KiKit_MB_27_3, KiKit_MB_27_4, KiKit_MB_27_5, KiKit_MB_27_6, KiKit_MB_28_1, KiKit_MB_28_2, KiKit_MB_28_3, KiKit_MB_28_4, KiKit_MB_28_5, KiKit_MB_28_6, KiKit_MB_29_1, KiKit_MB_29_2, KiKit_MB_29_3, KiKit_MB_29_4, KiKit_MB_29_5, KiKit_MB_29_6, KiKit_MB_30_1, KiKit_MB_30_2, KiKit_MB_30_3, KiKit_MB_30_4, KiKit_MB_30_5, KiKit_MB_30_6, KiKit_MB_31_1, KiKit_MB_31_2, KiKit_MB_31_3, KiKit_MB_31_4, KiKit_MB_31_5, KiKit_MB_31_6, KiKit_MB_32_1, KiKit_MB_32_2, KiKit_MB_32_3, KiKit_MB_32_4, KiKit_MB_32_5, KiKit_MB_32_6, KiKit_MB_33_1, KiKit_MB_33_2, KiKit_MB_33_3, KiKit_MB_33_4, KiKit_MB_33_5, KiKit_MB_33_6, KiKit_MB_34_1, KiKit_MB_34_2, KiKit_MB_34_3, KiKit_MB_34_4, KiKit_MB_34_5, KiKit_MB_34_6, KiKit_MB_35_1, KiKit_MB_35_2, KiKit_MB_35_3, KiKit_MB_35_4, KiKit_MB_35_5, KiKit_MB_35_6, KiKit_MB_36_1, KiKit_MB_36_2, KiKit_MB_36_3, KiKit_MB_36_4, KiKit_MB_36_5, KiKit_MB_36_6, KiKit_MB_37_1, KiKit_MB_37_2, KiKit_MB_37_3, KiKit_MB_37_4, KiKit_MB_37_5, KiKit_MB_37_6, KiKit_MB_38_1, KiKit_MB_38_2, KiKit_MB_38_3, KiKit_MB_38_4, KiKit_MB_38_5, KiKit_MB_38_6, KiKit_MB_39_1, KiKit_MB_39_2, KiKit_MB_39_3, KiKit_MB_39_4, KiKit_MB_39_5, KiKit_MB_39_6, KiKit_MB_40_1, KiKit_MB_40_2, KiKit_MB_40_3, KiKit_MB_40_4, KiKit_MB_40_5, KiKit_MB_40_6, KiKit_MB_41_1, KiKit_MB_41_2, KiKit_MB_41_3, KiKit_MB_41_4, KiKit_MB_41_5, KiKit_MB_41_6, KiKit_MB_42_1, KiKit_MB_42_2, KiKit_MB_42_3, KiKit_MB_42_4, KiKit_MB_42_5, KiKit_MB_42_6, KiKit_MB_43_1, KiKit_MB_43_2, KiKit_MB_43_3, KiKit_MB_43_4, KiKit_MB_43_5, KiKit_MB_43_6, KiKit_MB_44_1, KiKit_MB_44_2, KiKit_MB_44_3, KiKit_MB_44_4, KiKit_MB_44_5, KiKit_MB_44_6, KiKit_MB_45_1, KiKit_MB_45_2, KiKit_MB_45_3, KiKit_MB_45_4, KiKit_MB_45_5, KiKit_MB_45_6, KiKit_MB_46_1, KiKit_MB_46_2, KiKit_MB_46_3, KiKit_MB_46_4, KiKit_MB_46_5, KiKit_MB_46_6, KiKit_MB_47_1, KiKit_MB_47_2, KiKit_MB_47_3, KiKit_MB_47_4, KiKit_MB_47_5, KiKit_MB_47_6, KiKit_MB_48_1, KiKit_MB_48_2, KiKit_MB_48_3, KiKit_MB_48_4, KiKit_MB_48_5, KiKit_MB_48_6, KiKit_MB_49_1, KiKit_MB_49_2, KiKit_MB_49_3, KiKit_MB_49_4, KiKit_MB_49_5, KiKit_MB_49_6, KiKit_MB_50_1, KiKit_MB_50_2, KiKit_MB_50_3, KiKit_MB_50_4, KiKit_MB_50_5, KiKit_MB_50_6, KiKit_MB_51_1, KiKit_MB_51_2, KiKit_MB_51_3, KiKit_MB_51_4, KiKit_MB_51_5, KiKit_MB_51_6, KiKit_MB_52_1, KiKit_MB_52_2, KiKit_MB_52_3, KiKit_MB_52_4, KiKit_MB_52_5, KiKit_MB_52_6: NPTH
KiKit_TO_1, KiKit_TO_2, KiKit_TO_3, KiKit_TO_4: NPTH
U1, U1#2, U1#3, U1#4, U1#5, U1#6, U1#7, U1#8, U1#9, U1#10: HM-TRP

Connections:
Board_0-/Config: J1#2.5, U1#5.5 (CONFIG)
Board_0-/DRX: J1#2.4, U1#5.4 (DRX)
Board_0-/DTX: J1#2.2, U1#5.2 (DTX)
Board_0-/Enable: J1#2.6, U1#5.6 (ENABLE)
Board_0-/Vcc: J1#2.1, U1#5.1 (Vcc)
Board_0-GND: J1#2.3, J2#3.2 (Ext), U1#5.3 (GND), U1#5.8 (GND)
Board_0-Net-(J2-In): J2#3.1 (In), U1#5.9 (ANT)
Board_1-/Config: J1#8.5, U1#8.5 (CONFIG)
Board_1-/DRX: J1#8.4, U1#8.4 (DRX)
Board_1-/DTX: J1#8.2, U1#8.2 (DTX)
Board_1-/Enable: J1#8.6, U1#8.6 (ENABLE)
Board_1-/Vcc: J1#8.1, U1#8.1 (Vcc)
Board_1-GND: J1#8.3, J2#5.2 (Ext), U1#8.3 (GND), U1#8.8 (GND)
Board_1-Net-(J2-In): J2#5.1 (In), U1#8.9 (ANT)
Board_2-/Config: J1#3.5, U1.5 (CONFIG)
Board_2-/DRX: J1#3.4, U1.4 (DRX)
Board_2-/DTX: J1#3.2, U1.2 (DTX)
Board_2-/Enable: J1#3.6, U1.6 (ENABLE)
Board_2-/Vcc: J1#3.1, U1.1 (Vcc)
Board_2-GND: J1#3.3, J2#6.2 (Ext), U1.3 (GND), U1.8 (GND)
Board_2-Net-(J2-In): J2#6.1 (In), U1.9 (ANT)
Board_3-/Config: J1.5, U1#2.5 (CONFIG)
Board_3-/DRX: J1.4, U1#2.4 (DRX)
Board_3-/DTX: J1.2, U1#2.2 (DTX)
Board_3-/Enable: J1.6, U1#2.6 (ENABLE)
Board_3-/Vcc: J1.1, U1#2.1 (Vcc)
Board_3-GND: J1.3, J2#10.2 (Ext), U1#2.3 (GND), U1#2.8 (GND)
Board_3-Net-(J2-In): J2#10.1 (In), U1#2.9 (ANT)
Board_4-/Config: J1#5.5, U1#3.5 (CONFIG)
Board_4-/DRX: J1#5.4, U1#3.4 (DRX)
Board_4-/DTX: J1#5.2, U1#3.2 (DTX)
Board_4-/Enable: J1#5.6, U1#3.6 (ENABLE)
Board_4-/Vcc: J1#5.1, U1#3.1 (Vcc)
Board_4-GND: J1#5.3, J2#8.2 (Ext), U1#3.3 (GND), U1#3.8 (GND)
Board_4-Net-(J2-In): J2#8.1 (In), U1#3.9 (ANT)
Board_5-/Config: J1#7.5, U1#7.5 (CONFIG)
Board_5-/DRX: J1#7.4, U1#7.4 (DRX)
Board_5-/DTX: J1#7.2, U1#7.2 (DTX)
Board_5-/Enable: J1#7.6, U1#7.6 (ENABLE)
Board_5-/Vcc: J1#7.1, U1#7.1 (Vcc)
Board_5-GND: J1#7.3, J2#7.2 (Ext), U1#7.3 (GND), U1#7.8 (GND)
Board_5-Net-(J2-In): J2#7.1 (In), U1#7.9 (ANT)
Board_6-/Config: J1#6.5, U1#10.5 (CONFIG)
Board_6-/DRX: J1#6.4, U1#10.4 (DRX)
Board_6-/DTX: J1#6.2, U1#10.2 (DTX)
Board_6-/Enable: J1#6.6, U1#10.6 (ENABLE)
Board_6-/Vcc: J1#6.1, U1#10.1 (Vcc)
Board_6-GND: J1#6.3, J2#2.2 (Ext), U1#10.3 (GND), U1#10.8 (GND)
Board_6-Net-(J2-In): J2#2.1 (In), U1#10.9 (ANT)
Board_7-/Config: J1#4.5, U1#6.5 (CONFIG)
Board_7-/DRX: J1#4.4, U1#6.4 (DRX)
Board_7-/DTX: J1#4.2, U1#6.2 (DTX)
Board_7-/Enable: J1#4.6, U1#6.6 (ENABLE)
Board_7-/Vcc: J1#4.1, U1#6.1 (Vcc)
Board_7-GND: J1#4.3, J2#9.2 (Ext), U1#6.3 (GND), U1#6.8 (GND)
Board_7-Net-(J2-In): J2#9.1 (In), U1#6.9 (ANT)
Board_8-/Config: J1#9.5, U1#4.5 (CONFIG)
Board_8-/DRX: J1#9.4, U1#4.4 (DRX)
Board_8-/DTX: J1#9.2, U1#4.2 (DTX)
Board_8-/Enable: J1#9.6, U1#4.6 (ENABLE)
Board_8-/Vcc: J1#9.1, U1#4.1 (Vcc)
Board_8-GND: J1#9.3, J2#4.2 (Ext), U1#4.3 (GND), U1#4.8 (GND)
Board_8-Net-(J2-In): J2#4.1 (In), U1#4.9 (ANT)
Board_9-/Config: J1#10.5, U1#9.5 (CONFIG)
Board_9-/DRX: J1#10.4, U1#9.4 (DRX)
Board_9-/DTX: J1#10.2, U1#9.2 (DTX)
Board_9-/Enable: J1#10.6, U1#9.6 (ENABLE)
Board_9-/Vcc: J1#10.1, U1#9.1 (Vcc)
Board_9-GND: J1#10.3, J2.2 (Ext), U1#9.3 (GND), U1#9.8 (GND)
Board_9-Net-(J2-In): J2.1 (In), U1#9.9 (ANT)

File Pannel/production/BOM Pannel.xlsx:

Designator | Footprint | Quantity | Value | LCSC Part #
J1_10, J1_9, J1_8, J1_7, J1_6, J1_5, J1_4, J1_3, J1_2, J1 | WAFER-GH1.25-6PWB | 10 | Conn_01x06 | C3029381
J2_10, J2_9, J2_8, J2_7, J2_6, J2_5, J2_4, J2_3, J2_2, J2 | U.FL_Molex_MCRF_73412-0110_Vertical | 10 | Conn_Coaxial | C88373
